options:
  parameters:
    generate_options: qt_gui
    id: Tx_qpsk
    output_language: python
    title: Tx_qpsk
  states: {}

blocks:
- name: d
  id: variable
  parameters:
    value: 10/(2**(1/2))
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: enc_dummy
  id: variable_dummy_encoder_def
  parameters:
    framebits: frame_size*8
    ndim: '0'
  states: {}
- name: filt_delay
  id: variable
  parameters:
    value: int(1+(taps_per_filt-1)//2)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2400e6
  states: {}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pld_const
  id: variable_constellation_rect
  parameters:
    const_points: '[d+d*1j, -d+d*1j,-d-d*1j, d-d*1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: psf_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 15*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps_per_filt
  id: variable
  parameters:
    value: int(len(psf_taps)/nfilts)
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\usuario\Downloads\montanas-rocosas-canada-650x367.jpg
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: pld_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: hdr_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_size
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: complex
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: '"packet_len"'
    post_padding: '10'
    pre_padding: '10'
    type: complex
    window: firdes.window(firdes.WIN_HANN, 50, 0)
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: pld_const.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: hdr_const.points()
  states: {}
- name: digital_crc32_bb_1_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_encoder_bb_0_0_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(pld_const.points())
  states: {}
- name: digital_diff_encoder_bb_0_1
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(hdr_const.points())
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '60'
  states: {}
- name: hdr_const
  id: parameter
  parameters:
    label: Header constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0,2)
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: sps
    samp_delay: filt_delay
    taps: psf_taps
    type: ccf
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: I
    label2: Q
    name: '"Tx Signal"'
    size: 1024*4
    srate: 1e6
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: I
    label2: Q
    name: '"Tx Symbols"'
    size: '1512'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: '"serial=31BA199"'
    dev_args: '""'
    gain0: gain_tx
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: Tx Symbols
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: Tx Symbols
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_repack_bits_bb_0_0_1, '0', digital_diff_encoder_bb_0_0_0, '0']
- [blocks_repack_bits_bb_0_1, '0', digital_diff_encoder_bb_0_1, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_1_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_1_0, '0']
- [digital_burst_shaper_xx_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_chunks_to_symbols_xx_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [digital_crc32_bb_1_0, '0', blocks_repack_bits_bb_0_0_1, '0']
- [digital_crc32_bb_1_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [digital_diff_encoder_bb_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [digital_diff_encoder_bb_0_1, '0', digital_chunks_to_symbols_xx_0_1, '0']
- [digital_protocol_formatter_bb_0_0, '0', blocks_repack_bits_bb_0_1, '0']
- [pfb_arb_resampler_xxx_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [virtual_source_0_1_0, '0', digital_burst_shaper_xx_0, '0']

metadata:
  file_format: 1
